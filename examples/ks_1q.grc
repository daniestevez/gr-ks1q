<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ks_1q</value></param>
<param><key>author</key><value>Daniel Estevez</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>KS-1Q test decoder</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>KS-1Q test decoder</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>2.4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0_0_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>c</key><value>1/8.0</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>c</key><value>1/8.0</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0_0_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>ks1q.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>csp_check_crc</key>
<param><key>id</key><value>csp_check_crc_0</value></param>
<param><key>force</key><value>True</value></param>
<param><key>include_header</key><value>False</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>csp_print_header</key>
<param><key>id</key><value>csp_print_header_0</value></param>
</block>
<block>
<key>csp_swap_header</key>
<param><key>id</key><value>csp_swap_header_0</value></param>
</block>
<block>
<key>digital_additive_scrambler_bb</key>
<param><key>id</key><value>digital_additive_scrambler_bb_0</value></param>
<param><key>bits_per_byte</key><value>1</value></param>
<param><key>count</key><value>0</value></param>
<param><key>len</key><value>7</value></param>
<param><key>mask</key><value>0xA9 + 0*10101001</value></param>
<param><key>reset_tag_key</key><value>"packet_len"</value></param>
<param><key>seed</key><value>0x7F</value></param>
</block>
<block>
<key>digital_additive_scrambler_bb</key>
<param><key>id</key><value>digital_additive_scrambler_bb_0_0</value></param>
<param><key>bits_per_byte</key><value>1</value></param>
<param><key>count</key><value>0</value></param>
<param><key>len</key><value>7</value></param>
<param><key>mask</key><value>0xA9 + 0*10101001</value></param>
<param><key>reset_tag_key</key><value>"packet_len"</value></param>
<param><key>seed</key><value>0x7F</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>samp_per_sym*(1+0.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_bb</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0_0</value></param>
<param><key>access_code</key><value>00011010110011111111110000011101</value></param>
<param><key>tagname</key><value>syncword</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_bb</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0_0_0</value></param>
<param><key>access_code</key><value>00011010110011111111110000011101</value></param>
<param><key>tagname</key><value>syncword</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>fec_decode_ccsds_27_fb</key>
<param><key>id</key><value>fec_decode_ccsds_27_fb_0_0</value></param>
</block>
<block>
<key>fec_decode_ccsds_27_fb</key>
<param><key>id</key><value>fec_decode_ccsds_27_fb_0_0_0</value></param>
</block>
<block>
<key>kiss_kiss_to_pdu</key>
<param><key>id</key><value>kiss_kiss_to_pdu_0</value></param>
</block>
<block>
<key>ks1q_header_remover</key>
<param><key>id</key><value>ks1q_header_remover_0</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>libfec_decode_rs</key>
<param><key>id</key><value>libfec_decode_rs_0</value></param>
<param><key>basis</key><value>1</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>11e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>2e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>synctags_fixedlen_tagger</key>
<param><key>id</key><value>synctags_fixedlen_tagger_0_0</value></param>
<param><key>packetlen_tag</key><value>packet_len</value></param>
<param><key>packet_len</key><value>255*8</value></param>
<param><key>stream_type</key><value>byte</value></param>
<param><key>syncword_tag</key><value>syncword</value></param>
</block>
<block>
<key>synctags_fixedlen_tagger</key>
<param><key>id</key><value>synctags_fixedlen_tagger_0_0_0</value></param>
<param><key>packetlen_tag</key><value>packet_len</value></param>
<param><key>packet_len</key><value>255*8</value></param>
<param><key>stream_type</key><value>byte</value></param>
<param><key>syncword_tag</key><value>syncword</value></param>
</block>
<connection><source_block_id>blocks_deinterleave_0_0</source_block_id><sink_block_id>blocks_interleave_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0_0</source_block_id><sink_block_id>blocks_interleave_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_deinterleave_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0_0</source_block_id><sink_block_id>fec_decode_ccsds_27_fb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0_0_0</source_block_id><sink_block_id>fec_decode_ccsds_27_fb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_interleave_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_interleave_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0_0_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>kiss_kiss_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>libfec_decode_rs_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0_0</source_block_id><sink_block_id>libfec_decode_rs_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0_0_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>csp_check_crc_0</source_block_id><sink_block_id>csp_swap_header_0</sink_block_id><source_key>ok</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>csp_swap_header_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>csp_swap_header_0</source_block_id><sink_block_id>csp_print_header_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_additive_scrambler_bb_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_additive_scrambler_bb_0_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>blocks_deinterleave_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0_0</source_block_id><sink_block_id>synctags_fixedlen_tagger_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0_0_0</source_block_id><sink_block_id>synctags_fixedlen_tagger_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_decode_ccsds_27_fb_0_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_decode_ccsds_27_fb_0_0_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiss_kiss_to_pdu_0</source_block_id><sink_block_id>csp_check_crc_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ks1q_header_remover_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>libfec_decode_rs_0</source_block_id><sink_block_id>ks1q_header_remover_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>synctags_fixedlen_tagger_0_0</source_block_id><sink_block_id>digital_additive_scrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>synctags_fixedlen_tagger_0_0_0</source_block_id><sink_block_id>digital_additive_scrambler_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
